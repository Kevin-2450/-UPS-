# Keil uVision project FW.uvprojx, settings and files
target Target_1 (6230000::V6.23::ARMCLANG)
  device: STM32F030F4Px STMicroelectronics
  pack: Keil.STM32F0xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x00001000) IROM(0x08000000,0x00004000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: FW +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F030,USE_STDPERIPH_DRIVER,
  c misc: -finput-charset=UTF-8
  c include: ..\USER;..\CSMIS;..\HARDWARE;..\FWLIB\inc;..\SYSTEM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group USER
    ./: main.c isr.c
  group STARTUP
    ./: startup_stm32f030.s
  group HARDWARE
    ../HARDWARE/: led.c uart.c i2c.c tim.c husb238.c sc8886.c key.c
  group FWLIB
    ../FWLIB/src/: stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group SYSTEM
    ../SYSTEM/: delay.c system_stm32f0xx.c
software components: CMSIS:CORE 6.1.0
